# Keil uVision project GimbalFOC.uvprojx, settings and files
target GimbalFOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: gimbal_foc +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,HSE_VALUE=8000000U
  c include: ..\Config;..\App\Inc;..\Communication\Inc;..\BSP\Inc;..\Control\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\Core\Linker\STM32F103C8TX_FLASH.sct
  group Core
    ../Core/Startup/: startup_stm32f103xb_arm.s
    ../Core/Src/: main.c system_stm32f1xx.c
    ../Core/Linker/: STM32F103C8TX_FLASH.sct
  group App
    ../App/Src/: app_trace.c app.c
  group Communication
    ../Communication/Src/: can_protocol.c can_service.c console.c
  group BSP
    ../BSP/Src/: board_calibration.c board_can.c board_node_config.c board.c calibration_store.c node_id_store.c
  group Control
    ../Control/Src/: foc_parameters.c foc.c
  group Config
    ../Config/: board_config.h bringup_config.h can_config.h current_sense_config.h motor_config.h motor_profile.h motor_setup.h motor_tuning_defaults.h parameter_catalog.def
target OpenLoopTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: gimbal_foc +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,HSE_VALUE=8000000U,MOTOR_OPEN_AUTOTEST=1
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\Core\Linker\STM32F103C8TX_FLASH.sct
